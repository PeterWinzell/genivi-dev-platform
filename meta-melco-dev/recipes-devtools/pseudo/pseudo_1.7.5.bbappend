FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://pseudo_wrappers.patch"

