FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://v2-krogoth-nss-Disable-warning-on-deprecated-API-usage.patch"

